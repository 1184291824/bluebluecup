# Keil uVision project responder.uvproj, settings and files
target 抢答器 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: responder +hex
  c flags: Optimize=8 SizeSpeed=1
  group 库
    ./: STARTUP.A51
  group 应用程序
    ./: lcd1602.c main.c timer.c keyScan.c
